options:
  parameters:
    generate_options: qt_gui
    id: fmradio
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: baseline_chips
  id: variable
  parameters:
    value: '16'
  states: {}
- name: baseline_len
  id: variable
  parameters:
    value: ' max(1,int(chip_samples * baseline_chips))'
  states: {}
- name: baseline_scale
  id: variable
  parameters:
    value: 1.0 / baseline_len
  states: {}
- name: carrier
  id: variable
  parameters:
    value: 40.68e6
  states: {}
- name: chip_samples
  id: variable
  parameters:
    value: rx_rate * chip_time
  states: {}
- name: chip_time
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: demod_rate
  id: variable
  parameters:
    value: xlate_rate/lpf_decim
  states: {}
- name: display_chips
  id: variable
  parameters:
    value: '30'
  states: {}
- name: display_points
  id: variable
  parameters:
    value: int(chip_samples * display_chips)
  states: {}
- name: keep_n
  id: variable
  parameters:
    value: max(1, int(demod_rate * chip_time / samples_per_chip))
  states: {}
- name: lpf_decim
  id: variable
  parameters:
    value: '10'
  states: {}
- name: offset
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: rx_rate
  id: variable
  parameters:
    value: demod_rate/keep_n
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: samples_per_chip
  id: variable
  parameters:
    value: '10'
  states: {}
- name: smooth_fraction
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: smooth_len
  id: variable
  parameters:
    value: max(1,int(demod_rate * chip_time * smooth_fraction))
  states: {}
- name: smooth_scale
  id: variable
  parameters:
    value: 1.0/smooth_len
  states: {}
- name: target_freq
  id: variable
  parameters:
    value: carrier-offset
  states: {}
- name: xlate_decim
  id: variable
  parameters:
    value: '10'
  states: {}
- name: xlate_rate
  id: variable
  parameters:
    value: samp_rate/xlate_decim
  states: {}
- name: xlate_taps
  id: variable
  parameters:
    value: firdes.low_pass(    1.0,    samp_rate,    10e3,    5e3,    window.WIN_HAMMING)
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: keep_n
    type: float
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: smooth_len
    max_iter: '4000'
    scale: smooth_scale
    type: float
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: baseline_len
    max_iter: '4000'
    scale: baseline_scale
    type: float
  states: {state: disabled}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """Weak-signal Manchester + Hamming(7,4) decoder for GNU Radio Companion.

      Connect averaged, non-thresholded RF power directly from Keep 1 in N.
      Transmitter format: 16-bit 1010... preamble (Manchester), followed by
      Hamming(7,4)-protected 16-bit length + payload + CRC-16/CCITT (crc_hqx, 0xffff),
      with all bits Manchester-encoded as 0 -> OFF,ON and 1 -> ON,OFF.

      This block searches for a preamble in the RAW power stream and decodes
      Manchester bits using the difference of mean received power between chips.
      It uses a soft-decision Hamming decoder to exploit weak-signal confidence.
      """

      import binascii
      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):
          PREAMBLE = "1010101010101010"

          def __init__(
              self,
              rx_rate=100.0,
              chip_time=0.1,
              max_payload=1024,
              guard_time=0.35,
              preamble_corr_min=0.78,
              debug=False,
          ):
              gr.sync_block.__init__(
                  self,
                  name="Weak-Signal Differential Manchester Decoder",
                  in_sig=[np.float32],
                  out_sig=[],
              )
              self.message_port_register_out(pmt.intern("out"))

              self.rx_rate = float(rx_rate)
              self.chip_time = float(chip_time)
              self.max_payload = int(max_payload)
              self.guard_samples = max(1, int(round(self.rx_rate * float(guard_time))))
              self.preamble_corr_min = float(preamble_corr_min)
              self.debug = bool(debug)

              if self.rx_rate <= 0 or self.chip_time <= 0:
                  raise ValueError("rx_rate and chip_time must both be positive")
              if self.max_payload < 0 or self.max_payload > 65535:
                  raise ValueError("max_payload must be between 0 and 65535")
              if not (0.0 < self.preamble_corr_min <= 1.0):
                  raise ValueError("preamble_corr_min must be in (0, 1]")

              exact_chip_samples = self.rx_rate * self.chip_time
              self.chip_samples = int(round(exact_chip_samples))
              if self.chip_samples < 5:
                  raise ValueError(
                      "At least 5 receiver samples/chip are needed; increase rx_rate "
                      "or chip_time."
                  )
              if abs(exact_chip_samples - self.chip_samples) > 0.01:
                  raise ValueError(
                      "rx_rate * chip_time must be nearly an integer to avoid timing drift. "
                      f"Got {exact_chip_samples:.5f}."
                  )

              # Integrate over the middle 60% of each chip; exclude transitions.
              self.mid_lo = int(np.floor(0.20 * self.chip_samples))
              self.mid_hi = int(np.ceil(0.80 * self.chip_samples))
              self.mid_width = self.mid_hi - self.mid_lo
              if self.mid_width < 1:
                  raise ValueError("Invalid chip integration window")

              preamble_chips = []
              for bit in self.PREAMBLE:
                  preamble_chips.extend((1, 0) if bit == "1" else (0, 1))
              self.preamble_chips = np.array(preamble_chips, dtype=np.int8)
              self.preamble_signs = (2 * self.preamble_chips - 1).astype(np.float64)
              self.preamble_chip_count = len(self.preamble_chips)  # 32
              self.preamble_samples = self.preamble_chip_count * self.chip_samples
              self.chip_offsets = np.arange(self.preamble_chip_count) * self.chip_samples

              # Hamming(7,4): each codeword has 7 transmitted bits.
              codebook = []
              for v in range(16):
                  d1, d2, d3, d4 = ((v >> 3) & 1, (v >> 2) & 1,
                                    (v >> 1) & 1, v & 1)
                  codebook.append((d1 ^ d2 ^ d4, d1 ^ d3 ^ d4, d1,
                                   d2 ^ d3 ^ d4, d2, d3, d4))
              self.codebook = np.array(codebook, dtype=np.int8)
              # With D = second_power - first_power, bit=0 has positive D.
              self.codebook_signs = (1 - 2 * self.codebook).astype(np.float64)

              self.samples = np.empty(0, dtype=np.float64)
              self.state = "SEARCH"
              self.search_next = self.guard_samples
              self.payload_length = None
              self.preamble_gap = None

              print("Weak-signal differential Manchester decoder started", flush=True)
              print(
                  f"rx_rate={self.rx_rate:g}, chip_time={self.chip_time:g}, "
                  f"samples/chip={self.chip_samples}, "
                  f"preamble={self.preamble_chip_count} chips, "
                  f"guard={self.guard_samples} samples",
                  flush=True,
              )

          def _chip_averages(self, first_chip, chip_count):
              """Average the middle 60% of consecutive chips in the buffer."""
              indices = first_chip * self.chip_samples + (
                  np.arange(chip_count, dtype=np.int64) * self.chip_samples
              )
              start = indices + self.mid_lo
              stop = indices + self.mid_hi
              sums = np.concatenate(([0.0], np.cumsum(self.samples, dtype=np.float64)))
              return (sums[stop] - sums[start]) / self.mid_width

          def _find_preamble(self):
              """Search sample phases, requiring correlation and an OFF guard."""
              # Allow one additional chip of lookahead before committing, so the
              # chosen alignment can be optimized within its 1-chip neighborhood.
              last_ready = len(self.samples) - self.preamble_samples - self.chip_samples
              first = max(self.search_next, self.guard_samples)
              if last_ready < first:
                  return False

              # Examine one additional chip of candidate phases before accepting
              # the earliest valid preamble start. Without this lookahead, a weak
              # correlation can lock several samples EARLY at a transition.
              last_evaluable = len(self.samples) - self.preamble_samples
              starts = np.arange(first, last_evaluable + 1, dtype=np.int64)
              cs = np.concatenate(([0.0], np.cumsum(self.samples, dtype=np.float64)))
              chip_starts = starts[:, None] + self.chip_offsets[None, :]
              chip_means = (
                  cs[chip_starts + self.mid_hi] - cs[chip_starts + self.mid_lo]
              ) / self.mid_width

              on_means = chip_means[:, self.preamble_chips == 1]
              off_means = chip_means[:, self.preamble_chips == 0]
              high = on_means.mean(axis=1)
              low = off_means.mean(axis=1)
              gap = high - low

              centered = chip_means - chip_means.mean(axis=1, keepdims=True)
              denom = np.sqrt(
                  np.sum(centered * centered, axis=1)
                  * float(self.preamble_chip_count)
              )
              corr = np.divide(
                  centered @ self.preamble_signs,
                  denom,
                  out=np.zeros_like(gap),
                  where=denom > 1e-20,
              )

              # The transmitter sends 1.5 seconds of OFF guard before the
              # preamble. Reject a candidate if that region is not OFF-like.
              guard_avg = (
                  cs[starts] - cs[starts - self.guard_samples]
              ) / self.guard_samples
              guard_valid = guard_avg < low + 0.40 * gap

              # Do not lock onto a partial preamble that starts several whole
              # Manchester bits early in the guard. The repeating 1001... pattern
              # otherwise makes such partial matches score surprisingly well.
              # The first 4 chips must actually resemble ON, OFF, OFF, ON.
              midlevel = (high + low) / 2.0
              preamble_start_valid = (
                  (chip_means[:, 0] > midlevel)
                  & (chip_means[:, 1] < midlevel)
                  & (chip_means[:, 2] < midlevel)
                  & (chip_means[:, 3] > midlevel)
              )

              # A normalized match rejects flat/noise-only intervals without any
              # absolute amplitude threshold (which varies with antenna position).
              valid = (
                  (corr >= self.preamble_corr_min) & (gap > 0.0)
                  & guard_valid & preamble_start_valid
              )
              viable = np.flatnonzero(valid)
              ready = viable[starts[viable] <= last_ready]
              if ready.size == 0:
                  self.search_next = int(last_ready) + 1
                  # Retain OFF guard immediately preceding any candidate that has
                  # not yet been scanned; bound memory during long idle periods.
                  discard = max(0, self.search_next - self.guard_samples)
                  if discard:
                      self.samples = self.samples[discard:].copy()
                      self.search_next -= discard
                  return False

              # Find the best phase near the first plausible frame start, rather
              # than accidentally locking to an earlier, partly aligned edge.
              first_index = int(ready[0])
              neighborhood = viable[viable <= first_index + self.chip_samples]
              best = int(neighborhood[np.argmax(corr[neighborhood])])
              start = int(starts[best])
              self.preamble_gap = float(gap[best])

              if self.debug:
                  print(
                      f"Preamble: corr={corr[best]:.3f}, "
                      f"OFF={low[best]:.4e}, ON={high[best]:.4e}, "
                      f"gap={self.preamble_gap:.4e}, "
                      f"phase={start % self.chip_samples}",
                      flush=True,
                  )
              else:
                  print(f"Preamble detected (correlation={corr[best]:.3f})", flush=True)

              # Buffer now begins with the first preamble chip.
              self.samples = self.samples[start:].copy()
              self.state = "FRAME"
              self.payload_length = None
              return True

          def _differential_bits(self, start_chip, encoded_bit_count):
              """Return signed per-bit energy differences (second minus first)."""
              mean_power = self._chip_averages(start_chip, 2 * encoded_bit_count)
              return mean_power[1::2] - mean_power[0::2]

          def _decode_hamming_soft(self, differences):
              """ML/soft-decision decoding of Hamming(7,4) using signed energies."""
              if len(differences) % 7:
                  raise ValueError("Expected groups of 7 encoded Hamming bits")
              words = differences.reshape(-1, 7)
              # A codeword gets a positive score when its predicted bit sign
              # matches each observed Manchester power difference.
              scores = words @ self.codebook_signs.T
              choices = np.argmax(scores, axis=1)
              # Count changes relative to naive sign-only Manchester decisions.
              raw_bits = (words < 0).astype(np.int8)
              corrections = int(np.count_nonzero(raw_bits != self.codebook[choices]))
              data_bits = "".join(f"{int(v):04b}" for v in choices)
              return data_bits, corrections

          def _reject(self, reason):
              print(f"Frame rejected: {reason}", flush=True)
              # Do not lock endlessly on the same candidate. Keep already-
              # buffered later samples to allow searching for subsequent frames.
              self.samples = self.samples[self.chip_samples:].copy()
              self.state = "SEARCH"
              self.payload_length = None
              self.search_next = self.guard_samples

          def _process_frame(self):
              # The 16 length bits are protected by four Hamming(7,4) words:
              # 28 encoded bits, 56 Manchester chips, after 32 preamble chips.
              header_chips = self.preamble_chip_count + 2 * 28
              if len(self.samples) < header_chips * self.chip_samples:
                  return False

              if self.payload_length is None:
                  d = self._differential_bits(self.preamble_chip_count, 28)
                  header_bits, _ = self._decode_hamming_soft(d)
                  length = int(header_bits, 2)
                  if length > self.max_payload:
                      self._reject(f"invalid payload length {length} (max={self.max_payload})")
                      return True
                  self.payload_length = length
                  if self.debug:
                      print(f"Payload length: {length} bytes", flush=True)

              # Protected body = 16-bit length + payload + 16-bit CRC.
              data_bits = 32 + 8 * self.payload_length
              coded_bits = (data_bits // 4) * 7
              total_chips = self.preamble_chip_count + 2 * coded_bits
              needed = total_chips * self.chip_samples
              if len(self.samples) < needed:
                  return False

              differences = self._differential_bits(self.preamble_chip_count, coded_bits)
              recovered, corrections = self._decode_hamming_soft(differences)
              length = int(recovered[:16], 2)
              if length != self.payload_length:
                  self._reject("header length mismatch")
                  return True

              payload_bits = recovered[16:16 + 8 * length]
              received_crc = int(recovered[16 + 8 * length:32 + 8 * length], 2)
              payload = bytes(
                  int(payload_bits[i:i + 8], 2)
                  for i in range(0, len(payload_bits), 8)
              )
              calculated_crc = binascii.crc_hqx(payload, 0xFFFF)
              if received_crc != calculated_crc:
                  self._reject(
                      f"CRC mismatch (received 0x{received_crc:04x}, "
                      f"calculated 0x{calculated_crc:04x})"
                  )
                  return True

              try:
                  message = payload.decode("utf-8")
              except UnicodeDecodeError:
                  self._reject("valid CRC but invalid UTF-8 payload")
                  return True

              print(
                  f"DECODED MESSAGE: {message!r} "
                  f"(soft-Hamming corrections={corrections})",
                  flush=True,
              )
              self.message_port_pub(pmt.intern("out"), pmt.to_pmt(message))

              # Drop only the decoded frame, leaving any subsequent OFF guard
              # and new transmission in the stream.
              self.samples = self.samples[needed:].copy()
              self.state = "SEARCH"
              self.payload_length = None
              self.search_next = self.guard_samples
              return True

          def work(self, input_items, output_items):
              x = input_items[0]
              if len(x) == 0:
                  return 0
              self.samples = np.concatenate((self.samples, np.asarray(x, dtype=np.float64)))

              # Process data in chunks, not one Python iteration per SDR sample.
              # The loop may decode multiple frames if they arrived in one chunk.
              for _ in range(20):
                  if self.state == "SEARCH":
                      if not self._find_preamble():
                          break
                  elif self.state == "FRAME":
                      if not self._process_frame():
                          break
                  else:
                      raise RuntimeError(f"Unexpected decoder state: {self.state}")
              return len(x)
    chip_time: chip_time
    debug: 'True'
    guard_time: '0.35'
    max_payload: '1024'
    preamble_corr_min: '0.78'
    rx_rate: rx_rate
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: offset
    decim: xlate_decim
    samp_rate: samp_rate
    taps: xlate_taps
    type: ccc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '2000'
    decim: lpf_decim
    gain: '1'
    samp_rate: samp_rate/xlate_decim
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: target_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: display_points
    srate: rx_rate
    type: float
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: '"buffers=64"'
    bb_gain0: '20'
    bw0: 500e3
    freq0: carrier - offset
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_keep_one_in_n_0, '0', epy_block_1, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_keep_one_in_n_0, '0']
- [epy_block_1, out, blocks_message_debug_0, print]
- [freq_xlating_fir_filter_xxx_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_squared_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
