options:
  parameters:
    generate_options: qt_gui
    id: fmradio
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: baseline_chips
  id: variable
  parameters:
    value: '16'
  states: {}
- name: baseline_len
  id: variable
  parameters:
    value: ' max(1,int(chip_samples * baseline_chips))'
  states: {}
- name: baseline_scale
  id: variable
  parameters:
    value: 1.0 / baseline_len
  states: {}
- name: carrier
  id: variable
  parameters:
    value: 40.68e6
  states: {}
- name: chip_samples
  id: variable
  parameters:
    value: rx_rate * chip_time
  states: {}
- name: chip_time
  id: variable
  parameters:
    value: '0.02'
  states: {}
- name: demod_rate
  id: variable
  parameters:
    value: samp_rate / xlate_decim
  states: {}
- name: display_chips
  id: variable
  parameters:
    value: '30'
  states: {}
- name: display_points
  id: variable
  parameters:
    value: int(chip_samples * display_chips)
  states: {}
- name: keep_n
  id: variable
  parameters:
    value: max(1, int(demod_rate * chip_time / samples_per_chip))
  states: {}
- name: offset
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: rx_rate
  id: variable
  parameters:
    value: demod_rate/keep_n
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: samples_per_chip
  id: variable
  parameters:
    value: '100'
  states: {}
- name: smooth_fraction
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: smooth_len
  id: variable
  parameters:
    value: max(1,int(demod_rate * chip_time * smooth_fraction))
  states: {}
- name: smooth_scale
  id: variable
  parameters:
    value: 1.0/smooth_len
  states: {}
- name: target_freq
  id: variable
  parameters:
    value: carrier-offset
  states: {}
- name: xlate_decim
  id: variable
  parameters:
    value: '10'
  states: {}
- name: xlate_taps
  id: variable
  parameters:
    value: firdes.low_pass(    1.0,    samp_rate,    10e3,    5e3,    window.WIN_HAMMING)
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: keep_n
    type: float
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: smooth_len
    max_iter: '4000'
    scale: smooth_scale
    type: float
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: baseline_len
    max_iter: '4000'
    scale: baseline_scale
    type: float
  states: {state: disabled}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import binascii


      class blk(gr.sync_block):

          PREAMBLE = "1010101010101010"

          def __init__(
              self,
              rx_rate=400.0,
              chip_time=0.25,
              min_silence_time=0.50,
              first_center_fraction=0.40,
              max_payload=1024,
              debug_chips=True
          ):

              gr.sync_block.__init__(
                  self,
                  name="Manchester Hamming74 Frame Decoder",
                  in_sig=[np.float32],
                  out_sig=[]
              )

              # ====================================================
              # Timing configuration
              # ====================================================

              self.rx_rate = float(rx_rate)
              self.chip_time = float(chip_time)

              self.chip_samples = max(
                  4,
                  int(
                      round(
                          self.rx_rate
                          * self.chip_time
                      )
                  )
              )

              # Frame must be preceded by this much OFF time.
              self.min_silence_samples = max(
                  1,
                  int(
                      self.rx_rate
                      * min_silence_time
                  )
              )

              # The slicer has a small debounce delay.
              #
              # After observing the first rising edge, wait this
              # fraction of a chip so we sample near the center
              # of the first HIGH Manchester chip.
              self.first_center_delay = max(
                  1,
                  int(
                      self.chip_samples
                      * float(first_center_fraction)
                  )
              )

              self.max_payload = int(
                  max_payload
              )

              self.debug_chips = bool(
                  debug_chips
              )


              # ====================================================
              # Message output
              # ====================================================

              self.message_port_register_out(
                  pmt.intern("out")
              )


              # ====================================================
              # Build Hamming(7,4) codebook
              # ====================================================

              self.codebook = []

              for value in range(16):

                  data = [
                      (value >> 3) & 1,
                      (value >> 2) & 1,
                      (value >> 1) & 1,
                      value & 1
                  ]

                  codeword = self.hamming_encode(
                      data
                  )

                  self.codebook.append(
                      (
                          data,
                          codeword
                      )
                  )


              print(
                  "Manchester + Hamming(7,4) decoder started",
                  flush=True
              )

              print(
                  "rx_rate:",
                  self.rx_rate,
                  flush=True
              )

              print(
                  "chip_time:",
                  self.chip_time,
                  flush=True
              )

              print(
                  "samples/chip:",
                  self.chip_samples,
                  flush=True
              )

              print(
                  "minimum silence samples:",
                  self.min_silence_samples,
                  flush=True
              )

              print(
                  "first center delay:",
                  self.first_center_delay,
                  flush=True
              )


              self.reset()


          # ========================================================
          # Hamming(7,4) encoder
          #
          # Used to construct the decoder codebook.
          # ========================================================

          def hamming_encode(
              self,
              data
          ):

              d1, d2, d3, d4 = data

              # Hamming positions:
              #
              # 1 = p1
              # 2 = p2
              # 3 = d1
              # 4 = p4
              # 5 = d2
              # 6 = d3
              # 7 = d4

              p1 = (
                  d1
                  ^ d2
                  ^ d4
              )

              p2 = (
                  d1
                  ^ d3
                  ^ d4
              )

              p4 = (
                  d2
                  ^ d3
                  ^ d4
              )

              return [
                  p1,
                  p2,
                  d1,
                  p4,
                  d2,
                  d3,
                  d4
              ]


          # ========================================================
          # Hamming(7,4) decoder
          # ========================================================

          def hamming_decode(
              self,
              received
          ):

              """
              received contains seven values:

                  0
                  1
                  None

              None represents a Manchester erasure.

              We compare against all 16 valid Hamming codewords and
              choose the unique nearest codeword.
              """

              erasures = sum(
                  bit is None
                  for bit in received
              )

              candidates = []

              for data, codeword in self.codebook:

                  errors = 0

                  for r, c in zip(
                      received,
                      codeword
                  ):

                      if r is None:
                          continue

                      if r != c:
                          errors += 1


                  candidates.append(
                      (
                          errors,
                          data,
                          codeword
                      )
                  )


              minimum = min(
                  item[0]
                  for item in candidates
              )


              best = [
                  item
                  for item in candidates
                  if item[0] == minimum
              ]


              # More than one equally-good codeword means the result
              # is ambiguous.
              if len(best) != 1:

                  return None


              errors, data, codeword = best[0]


              # Hamming(7,4) has distance 3.
              #
              # Guaranteed correction condition:
              #
              #     2(errors) + erasures < 3

              if (
                  erasures > 0
                  and
                  (
                      2 * errors
                      + erasures
                  ) >= 3
              ):

                  return None


              corrected = (
                  errors > 0
                  or
                  erasures > 0
              )


              return {
                  "data": data,
                  "codeword": codeword,
                  "errors": errors,
                  "erasures": erasures,
                  "corrected": corrected
              }


          # ========================================================
          # Reset receiver
          # ========================================================

          def reset(self):

              # --------------------------------------------
              # Physical/frame synchronization
              # --------------------------------------------

              self.state = "WAIT"

              self.silence_count = 0

              # Counts down to next chip-center sample.
              self.center_count = 0


              # --------------------------------------------
              # Manchester decoder
              # --------------------------------------------

              self.chip_pair = []


              # --------------------------------------------
              # Protocol decoder
              # --------------------------------------------

              self.stage = "PREAMBLE"

              self.preamble_bits = ""

              self.hamming_buffer = []

              self.length_bits = ""

              self.payload_bits = ""

              self.crc_bits = ""

              self.payload_length = 0


              # --------------------------------------------
              # Statistics
              # --------------------------------------------

              self.corrected_words = 0

              self.uncorrectable_words = 0


          # ========================================================
          # Process one Manchester chip
          # ========================================================

          def process_chip(
              self,
              chip
          ):

              self.chip_pair.append(
                  chip
              )


              if len(self.chip_pair) < 2:

                  return


              first = self.chip_pair[0]

              second = self.chip_pair[1]

              self.chip_pair = []


              # ====================================================
              # Manchester decoding
              #
              # 0 -> 01
              # 1 -> 10
              # ====================================================

              if (
                  first == 0
                  and
                  second == 1
              ):

                  bit = 0


              elif (
                  first == 1
                  and
                  second == 0
              ):

                  bit = 1


              else:

                  print(
                      "Manchester erasure:",
                      first,
                      second,
                      flush=True
                  )


                  # The preamble is not protected by Hamming.
                  # If synchronization is wrong during the preamble,
                  # restart frame acquisition.
                  if self.stage == "PREAMBLE":

                      print(
                          "Lost synchronization during preamble",
                          flush=True
                      )

                      self.reset()

                      return


                  # Inside Hamming-protected data, preserve the bit
                  # position by inserting an erasure.
                  bit = None


              # ====================================================
              # Preamble
              # ====================================================

              if self.stage == "PREAMBLE":

                  self.process_preamble_bit(
                      bit
                  )

                  return


              # ====================================================
              # Hamming protected body
              # ====================================================

              self.process_hamming_bit(
                  bit
              )


          # ========================================================
          # Process preamble bit
          # ========================================================

          def process_preamble_bit(
              self,
              bit
          ):

              if bit is None:

                  self.reset()

                  return


              self.preamble_bits += str(
                  bit
              )


              if (
                  len(self.preamble_bits)
                  < len(self.PREAMBLE)
              ):

                  return


              if (
                  self.preamble_bits
                  != self.PREAMBLE
              ):

                  print(
                      "Bad preamble:",
                      self.preamble_bits,
                      flush=True
                  )

                  self.reset()

                  return


              print(
                  "Preamble detected",
                  flush=True
              )


              self.stage = "LENGTH"

              self.hamming_buffer = []


          # ========================================================
          # Process Hamming encoded bit stream
          # ========================================================

          def process_hamming_bit(
              self,
              bit
          ):

              self.hamming_buffer.append(
                  bit
              )


              if (
                  len(self.hamming_buffer)
                  < 7
              ):

                  return


              received = list(
                  self.hamming_buffer
              )

              self.hamming_buffer = []


              result = self.hamming_decode(
                  received
              )


              if result is None:

                  print(
                      "Uncorrectable Hamming codeword:",
                      received,
                      flush=True
                  )

                  self.uncorrectable_words += 1

                  self.reset()

                  return


              if result["corrected"]:

                  self.corrected_words += 1

                  print(
                      "Hamming corrected:",
                      received,
                      "->",
                      result["codeword"],
                      flush=True
                  )


              # One Hamming codeword recovers four original bits.
              for bit_value in result["data"]:

                  self.process_body_bit(
                      bit_value
                  )


          # ========================================================
          # Process original data after Hamming correction
          # ========================================================

          def process_body_bit(
              self,
              bit
          ):

              bit = str(
                  bit
              )


              # ====================================================
              # LENGTH
              # ====================================================

              if self.stage == "LENGTH":

                  self.length_bits += bit


                  if (
                      len(self.length_bits)
                      == 16
                  ):

                      self.payload_length = int(
                          self.length_bits,
                          2
                      )


                      print(
                          "Payload length:",
                          self.payload_length,
                          "bytes",
                          flush=True
                      )


                      if (
                          self.payload_length
                          > self.max_payload
                      ):

                          print(
                              "Invalid payload length",
                              flush=True
                          )

                          self.reset()

                          return


                      if (
                          self.payload_length
                          == 0
                      ):

                          self.stage = "CRC"

                      else:

                          self.stage = "PAYLOAD"


                  return


              # ====================================================
              # PAYLOAD
              # ====================================================

              if self.stage == "PAYLOAD":

                  self.payload_bits += bit


                  required = (
                      self.payload_length
                      * 8
                  )


                  if (
                      len(self.payload_bits)
                      >= required
                  ):

                      self.stage = "CRC"


                  return


              # ====================================================
              # CRC
              # ====================================================

              if self.stage == "CRC":

                  self.crc_bits += bit


                  if (
                      len(self.crc_bits)
                      == 16
                  ):

                      self.finish_frame()


                  return


          # ========================================================
          # Finish frame / verify CRC
          # ========================================================

          def finish_frame(self):

              payload = bytearray()


              for i in range(
                  0,
                  len(self.payload_bits),
                  8
              ):

                  byte_bits = (
                      self.payload_bits[
                          i:i + 8
                      ]
                  )


                  if len(byte_bits) == 8:

                      payload.append(
                          int(
                              byte_bits,
                              2
                          )
                      )


              received_crc = int(
                  self.crc_bits,
                  2
              )


              calculated_crc = (
                  binascii.crc_hqx(
                      payload,
                      0xFFFF
                  )
              )


              print(
                  "Received CRC:",
                  hex(received_crc),
                  flush=True
              )

              print(
                  "Calculated CRC:",
                  hex(calculated_crc),
                  flush=True
              )


              # ====================================================
              # CRC failure
              # ====================================================

              if (
                  received_crc
                  != calculated_crc
              ):

                  print(
                      "CRC FAILED",
                      flush=True
                  )

                  print(
                      "Hamming corrections:",
                      self.corrected_words,
                      flush=True
                  )

                  self.reset()

                  return


              # ====================================================
              # CRC success
              # ====================================================

              print(
                  "CRC OK",
                  flush=True
              )


              try:

                  text = bytes(
                      payload
                  ).decode(
                      "utf-8"
                  )


              except UnicodeDecodeError:

                  print(
                      "UTF-8 decoding failed",
                      flush=True
                  )

                  self.reset()

                  return


              print()

              print(
                  "==============================",
                  flush=True
              )

              print(
                  "DECODED MESSAGE:",
                  flush=True
              )

              print(
                  text,
                  flush=True
              )

              print(
                  "Hamming corrections:",
                  self.corrected_words,
                  flush=True
              )

              print(
                  "==============================",
                  flush=True
              )

              print()


              self.message_port_pub(
                  pmt.intern("out"),
                  pmt.to_pmt(
                      text
                  )
              )


              self.reset()


          # ========================================================
          # GNU Radio work()
          # ========================================================

          def work(
              self,
              input_items,
              output_items
          ):

              x = input_items[0]


              for sample in x:

                  # Slicer outputs approximately 0.0 / 1.0.
                  level = (
                      1
                      if sample >= 0.5
                      else 0
                  )


                  # =================================================
                  # STATE: WAIT
                  #
                  # Wait for a long OFF period followed by the first
                  # rising edge of the Manchester frame.
                  # =================================================

                  if self.state == "WAIT":

                      if level == 0:

                          self.silence_count += 1


                      else:

                          # Rising edge after sufficient OFF guard.
                          if (
                              self.silence_count
                              >= self.min_silence_samples
                          ):

                              print(
                                  "Frame start detected",
                                  flush=True
                              )


                              self.state = "RECEIVE"


                              # -------------------------------------
                              # We're near the beginning of the
                              # first HIGH chip.
                              #
                              # Wait until near its center.
                              # -------------------------------------

                              self.center_count = (
                                  self.first_center_delay
                              )


                          else:

                              # Not enough preceding silence.
                              self.silence_count = 0


                  # =================================================
                  # STATE: RECEIVE
                  #
                  # Sample one value near the center of every
                  # Manchester chip.
                  # =================================================

                  elif self.state == "RECEIVE":

                      self.center_count -= 1


                      if (
                          self.center_count
                          <= 0
                      ):

                          chip = level


                          if self.debug_chips:

                              print(
                                  "chip:",
                                  chip,
                                  flush=True
                              )


                          self.process_chip(
                              chip
                          )


                          # -----------------------------------------
                          # Next chip center is exactly one chip
                          # duration later.
                          # -----------------------------------------

                          self.center_count = (
                              self.chip_samples
                          )


              return len(x)
    chip_time: chip_time
    debug_chips: 'True'
    first_center_fraction: '0.4'
    max_payload: '1024'
    min_silence_time: '0.5'
    rx_rate: rx_rate
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):

          def __init__(
              self,
              rx_rate=400.0,
              chip_time=0.25,
              cal_off_time=1.0,
              on_detect_time=0.50,
              on_verify_time=1.00,
              guard_confirm_time=0.40,
              end_idle_time=3.0
          ):

              gr.sync_block.__init__(
                  self,
                  name="Adaptive OOK Slicer",
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )

              self.rx_rate = float(rx_rate)
              self.chip_time = float(chip_time)

              # A threshold crossing must persist for 10% of a chip
              # before the digital state changes.
              self.transition_samples = max(
                  2,
                  int(
                      self.rx_rate
                      * self.chip_time
                      * 0.10
                  )
              )

              print(
                  "Transition confirmation samples:",
                  self.transition_samples,
                  flush=True
              )
              # ====================================================
              # Convert durations to samples
              # ====================================================

              # How much idle/OFF data to use to determine LOW.
              self.off_samples_needed = max(
                  1,
                  int(self.rx_rate * cal_off_time)
              )

              # Sliding window used to initially identify carrier ON.
              self.on_detect_samples = max(
                  1,
                  int(self.rx_rate * on_detect_time)
              )

              # Total sustained ON duration required before
              # accepting the HIGH calibration.
              self.on_verify_samples = max(
                  1,
                  int(self.rx_rate * on_verify_time)
              )

              # Amount of sustained OFF required after calibration
              # before enabling the output.
              self.guard_confirm_samples = max(
                  1,
                  int(self.rx_rate * guard_confirm_time)
              )

              # Amount of sustained OFF used to determine that the
              # frame has ended.
              self.end_idle_samples = max(
                  1,
                  int(self.rx_rate * end_idle_time)
              )

              print(
                  "Adaptive OOK slicer started",
                  flush=True
              )

              print(
                  "rx_rate:",
                  self.rx_rate,
                  flush=True
              )

              print(
                  "OFF calibration samples:",
                  self.off_samples_needed,
                  flush=True
              )

              print(
                  "ON detect samples:",
                  self.on_detect_samples,
                  flush=True
              )

              print(
                  "ON verify samples:",
                  self.on_verify_samples,
                  flush=True
              )

              print(
                  "Guard samples:",
                  self.guard_confirm_samples,
                  flush=True
              )

              self.reset()


          # ========================================================
          # Reset state machine
          # ========================================================

          def reset(self):

              self.state = "CAL_OFF"

              self.rise_count = 0
              self.fall_count = 0
              self.off_buffer = []
              self.detect_buffer = []
              self.on_buffer = []
              self.guard_buffer = []
              self.low_level = None
              self.high_level = None
              self.low_noise = None
              self.on_detection_threshold = None
              self.threshold_low = None
              self.threshold_high = None

              self.output_state = 0

              self.guard_count = 0
              self.idle_count = 0

              self.false_on_count = 0


          # ========================================================
          # GNU Radio work function
          # ========================================================

          def work(
              self,
              input_items,
              output_items
          ):

              x = input_items[0]
              y = output_items[0]

              for i, sample in enumerate(x):

                  value = float(sample)


                  # =================================================
                  # STATE 1
                  #
                  # Measure carrier-OFF level
                  # =================================================

                  if self.state == "CAL_OFF":

                      # Never expose calibration to decoder.
                      y[i] = 0.0

                      self.off_buffer.append(
                          value
                      )

                      if (
                          len(self.off_buffer)
                          >= self.off_samples_needed
                      ):

                          n = len(
                              self.off_buffer
                          )

                          # Ignore first and last 10%.
                          lo = int(
                              0.10 * n
                          )

                          hi = int(
                              0.90 * n
                          )

                          middle = np.asarray(
                              self.off_buffer[lo:hi],
                              dtype=np.float64
                          )


                          # -----------------------------------------
                          # Robust estimate of LOW
                          # -----------------------------------------

                          median = float(
                              np.median(middle)
                          )

                          mad = float(
                              np.median(
                                  np.abs(
                                      middle - median
                                  )
                              )
                          )

                          self.low_level = median

                          # Convert MAD to approximate standard
                          # deviation.
                          self.low_noise = (
                              1.4826 * mad
                          )
                          self.on_detection_threshold = (
                              self.low_level
                              + max(
                                  2.5 * self.low_noise,
                                  abs(self.low_level) * 0.08
                              )
                          )
                          print(
                              "LOW level:",
                              self.low_level,
                              "noise:",
                              self.low_noise,
                              flush=True
                          )

                          # Freeze LOW and start searching for ON.
                          self.state = "WAIT_ON"

                          self.detect_buffer = []


                  # =================================================
                  # STATE 2
                  #
                  # Search for sustained increase that may be ON
                  # =================================================

                  elif self.state == "WAIT_ON":

                      y[i] = 0.0

                      self.detect_buffer.append(value)

                      if len(self.detect_buffer) > self.on_detect_samples:
                          self.detect_buffer.pop(0)

                      if len(self.detect_buffer) == self.on_detect_samples:

                          window = np.asarray(
                              self.detect_buffer,
                              dtype=np.float64
                          )

                          # Require the MEDIAN of the whole window to rise.
                          window_median = float(
                              np.median(window)
                          )

                          # Stronger ON requirement now that the antenna
                          # gives us much better separation.
                          rise_needed = max(
                              2.5 * self.low_noise,
                              abs(self.low_level) * 0.08
                          )

                          rise_threshold = self.on_detection_threshold

                          if window_median >= rise_threshold:

                              print(
                                  "ON candidate:",
                                  "level =",
                                  window_median,
                                  "required >=",
                                  rise_threshold,
                                  flush=True
                              )

                              self.on_buffer = list(
                                  self.detect_buffer
                              )

                              self.state = "VERIFY_ON"


                  # =================================================
                  # STATE 3
                  #
                  # Require sustained ON before accepting calibration
                  # =================================================

                  elif self.state == "VERIFY_ON":

                      y[i] = 0.0

                      self.on_buffer.append(
                          value
                      )


                      if (
                          len(self.on_buffer)
                          >= self.on_verify_samples
                      ):

                          on_data = np.asarray(
                              self.on_buffer,
                              dtype=np.float64
                          )

                          n = len(
                              on_data
                          )

                          # Ignore transition edges.
                          lo = int(
                              0.10 * n
                          )

                          hi = int(
                              0.90 * n
                          )

                          middle = on_data[
                              lo:hi
                          ]


                          candidate_high = float(
                              np.median(
                                  middle
                              )
                          )


                          gap = (
                              candidate_high
                              - self.low_level
                          )


                          # -----------------------------------------
                          # Verification threshold
                          #
                          # More strict than initial detection.
                          # -----------------------------------------

                          required_gap = max(
                              2.0 * self.low_noise,
                              abs(self.low_level) * 0.02
                          )


                          # -----------------------------------------
                          # False ON candidate
                          # -----------------------------------------

                          if gap < required_gap:

                              self.false_on_count += 1

                              # Don't spam the console.
                              # Print first rejection and then every
                              # fifth rejection for diagnostics.
                              if (
                                  self.false_on_count == 1
                                  or
                                  self.false_on_count % 5 == 0
                              ):

                                  print(
                                      "ON candidate rejected:",
                                      "HIGH =",
                                      candidate_high,
                                      "gap =",
                                      gap,
                                      "required >=",
                                      required_gap,
                                      "rejections =",
                                      self.false_on_count,
                                      flush=True
                                  )


                              # Do NOT recalibrate LOW.
                              #
                              # LOW is already known.
                              # Simply continue waiting for the real
                              # ON calibration burst.
                              self.state = "WAIT_ON"

                              self.detect_buffer = []
                              self.on_buffer = []

                              continue


                          # -----------------------------------------
                          # Real ON calibration accepted
                          # -----------------------------------------

                          self.high_level = (
                              candidate_high
                          )


                          print(
                              "ON CALIBRATION VERIFIED",
                              flush=True
                          )

                          print(
                              "LOW:",
                              self.low_level,
                              flush=True
                          )

                          print(
                              "HIGH:",
                              self.high_level,
                              flush=True
                          )

                          print(
                              "Signal gap:",
                              gap,
                              flush=True
                          )


                          # -----------------------------------------
                          # Calculate threshold
                          # -----------------------------------------

                          # Turn ON when signal reaches 40% of the distance
                          # from calibrated LOW to calibrated HIGH.
                          self.threshold_high = (
                              self.low_level
                              + 0.45 * gap
                          )

                          # Turn OFF when signal falls below 25% of the
                          # distance from LOW to HIGH.
                          self.threshold_low = (
                              self.low_level
                              + 0.2 * gap
                          )


                          print(
                              "Threshold low:",
                              self.threshold_low,
                              flush=True
                          )

                          print(
                              "Threshold high:",
                              self.threshold_high,
                              flush=True
                          )


                          # -----------------------------------------
                          # Do NOT activate yet.
                          #
                          # The transmitter is still inside its
                          # calibration ON period.
                          #
                          # Wait for the known OFF guard.
                          # -----------------------------------------

                          self.state = "WAIT_GUARD"

                          self.guard_count = 0

                          self.output_state = 0

                          self.detect_buffer = []
                          self.on_buffer = []


                  # =================================================
                  # STATE 4
                  #
                  # Wait for transmitter OFF guard
                  # =================================================

                  elif self.state == "WAIT_GUARD":

                      # Do not expose calibration/guard to decoder.
                      y[i] = 0.0

                      self.guard_buffer.append(value)

                      # Keep exactly guard_confirm_time worth of samples.
                      if len(self.guard_buffer) > self.guard_confirm_samples:
                          self.guard_buffer.pop(0)

                      if len(self.guard_buffer) == self.guard_confirm_samples:

                          guard = np.asarray(
                              self.guard_buffer,
                              dtype=np.float64
                          )

                          # What fraction of the guard window looks OFF?
                          below_fraction = float(
                              np.mean(
                                  guard <= self.threshold_low
                              )
                          )

                          # Also check median level.
                          guard_median = float(
                              np.median(guard)
                          )

                          # Do NOT require every sample to be perfect.
                          #
                          # Require:
                          #   - at least 80% of samples below threshold_low
                          #   - median below threshold_low
                          if (
                              below_fraction >= 0.80
                              and
                              guard_median <= self.threshold_low
                          ):

                              print(
                                  "OFF guard detected",
                                  "median =",
                                  guard_median,
                                  "below =",
                                  f"{below_fraction * 100:.1f}%",
                                  flush=True
                              )

                              print(
                                  "Slicer ACTIVE",
                                  flush=True
                              )

                              self.state = "ACTIVE"

                              self.output_state = 0
                              self.idle_count = 0

                              self.guard_buffer = []


                  # =================================================
                  # STATE 5
                  #
                  # Actual OOK data
                  # =================================================

                  elif self.state == "ACTIVE":

                      # =====================================================
                      # Currently OFF
                      # =====================================================

                      if self.output_state == 0:

                          # Signal must stay above HIGH threshold
                          # for multiple samples before changing to ON.
                          if value >= self.threshold_high:

                              self.rise_count += 1

                          else:

                              self.rise_count = 0


                          if self.rise_count >= self.transition_samples:

                              self.output_state = 1

                              self.rise_count = 0
                              self.fall_count = 0


                      # =====================================================
                      # Currently ON
                      # =====================================================

                      else:

                          # Signal must stay below LOW threshold
                          # for multiple samples before changing to OFF.
                          if value <= self.threshold_low:

                              self.fall_count += 1

                          else:

                              self.fall_count = 0


                          if self.fall_count >= self.transition_samples:

                              self.output_state = 0

                              self.fall_count = 0
                              self.rise_count = 0


                      # Output filtered digital state
                      y[i] = float(
                          self.output_state
                      )


                      # =====================================================
                      # End-of-frame detection
                      # =====================================================

                      if self.output_state == 0:

                          self.idle_count += 1

                      else:

                          self.idle_count = 0


                      if self.idle_count >= self.end_idle_samples:

                          print(
                              "End of frame detected",
                              flush=True
                          )

                          print(
                              "Returning to calibration",
                              flush=True
                          )

                          self.reset()


              return len(x)
    cal_off_time: '1.0'
    chip_time: chip_time
    end_idle_time: '3.0'
    guard_confirm_time: '0.4'
    on_detect_time: '0.5'
    on_verify_time: '1.00'
    rx_rate: rx_rate
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: offset
    decim: xlate_decim
    samp_rate: samp_rate
    taps: xlate_taps
    type: ccc
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: display_points
    srate: rx_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: display_points
    srate: rx_rate
    type: float
    ymax: '1.2'
    ymin: '-0.2'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    bw0: 500e3
    freq0: carrier - offset
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_keep_one_in_n_0, '0', epy_block_1, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_keep_one_in_n_0, '0']
- [epy_block_0, out, blocks_message_debug_0, print]
- [epy_block_1, '0', epy_block_0, '0']
- [epy_block_1, '0', qtgui_time_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
